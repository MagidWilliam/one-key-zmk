## boards/shields/xkey/Kconfig.shield
```kconfig
# Copyright (c) 2022 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_XKEY
    def_bool $(shields_list_contains,xkey)
```
